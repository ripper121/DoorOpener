# Keil uVision project Project.uvproj, settings and files
target Product_EU (MCS-51)
  device: ZW0301 Zensys
  cpu: IRAM(0-0x7F) XRAM(0-0x7FF) IROM(0-0x7FFF) CLOCK(32000000)
  output: Product_EU.aof +hex
  c flags: Optimize=12
  c define: ZW_SLAVE, ZW_SLAVE_32, ZW_SLAVE_ENHANCED_232, ZW_SLAVE_ROUTING, ZW050x, BANKING, EU
  c misc: DB OE NOCO SB LC CD
  c include: ..\..\Z-WAVE\INCLUDE;..\..\Z-WAVE\IO_DEFINES;C:\Keil\C51\INC
  asm misc: DF(ZW_SLAVE, ZW_SLAVE_32, ZW_SLAVE_ENHANCED_232, ZW_SLAVE_ROUTING, ZW050x, BANKING, EU)
  asm include: ..\..\Z-WAVE\INCLUDE;..\..\Z-WAVE\IO_DEFINES
  link misc: NOOVERLAY
  group Z-Wave Lib (COMMON forced)
    ../../Z-Wave/lib/ext_nvm/: ZW_generic_p0_4_spi1_if.obj
    ../../Z-Wave/lib/slave_enhanced_232_ZW050x/: ZW_slave_enhanced_232_ZW050x.lib
  group Z-Wave Lib (BANK1 forced)
    ../../Z-Wave/lib/slave_enhanced_232_ZW050x/: ZW_slave_enhanced_232_ZW050x.lib
  group Z-Wave.Me Template Includes
    ../ZWaveMeCommonFiles/: ZME_Eurotronics_StellaZ_UART.h ZME_Global.h ZME_I2C.h ZME_Includes.h ZME_LED.h ZME_Queue.h ZME_Slave_Learn.h ZME_Time.h ZME_FSM.h ZME_Security.h ZME_Utils.h ZME_Association.h ZME_Buttons.h ZME_Common.h
  group Z-Wave.Me Template Code (COMMON)
    ../ZWaveMeCommonFiles/: ZME_App_Version.c
  group Z-Wave.Me Template Code (BANK2)
    ../ZWaveMeCommonFiles/: ZME_Association.c ZME_Common.c ZME_LED.c ZME_Queue.c ZME_Slave_Learn.c ZME_Buttons.c ZME_FSM.c ZME_Security.c ZME_Utils.c ZME_Battery.c ZME_PowerLevel.c
  group Appl Source Code (BANK2)
    ./: Custom_Code.inc Custom_Includes.h Custom_pindefs.h Custom.h
  group Sigma Source Code (COMMON)
    ../../Z-WAVE/IO_DEFINES/: ZW_L51_BANK.A51 APP_RFSETUP.C
  group Z-Wave Lib (COMMON)
    ../../Z-WAVE/LIB/INIT_VARS/: INIT_VARS.OBJ
    C:/Keil/C51/LIB/: C51FPL.LIB C51L.LIB
    ../../Z-WAVE/LIB/RF_FREQ/: ZW_RF_050X_EU.OBJ
    ../../Z-Wave/lib/slave_enhanced_232_ZW050x/: ZW_slave_enhanced_232_ZW050x.lib
  group Z-Wave Inc
    ../../Z-WAVE/INCLUDE/: ZW_RF040X.H ZW_BASIS_API.H ZW_TYPEDEFS.H ZW_SYSDEFS.H ZW0X0X.H ZW050X.H ZW_TRANSPORT_API.H ZW_SECURITY_API.H ZW_TIMER_API.H ZW_MEM_API.H ZW_CLASSCMD.H ZW_UART_API.H ZW_SLAVE_API.H ZW_FIRMWARE_DESCRIPTOR.H ZW_NVM_DESCRIPTOR.H
    ../UTIL_FUNC/: ZW_TRANSPORTLAYER.H ZW_TRANSPORTNATIVE.H ZW_PRODUCT_ID_ENUM.H
    ../../Z-WAVE/IO_DEFINES/: ZW_PINDEFS.H ZW_EVALDEFS.H
